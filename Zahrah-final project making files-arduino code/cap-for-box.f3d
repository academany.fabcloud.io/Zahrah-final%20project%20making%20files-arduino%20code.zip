cap-for-box (Autodesk Fusion 360 design; units mm, degrees)
sketch "cap-for-box"