table-support (Autodesk Fusion 360 design; units mm, degrees)
sketch "box-slots"